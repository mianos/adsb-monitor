## main/Kconfig.projbuild
```kconfig
menu "ADS-B monitor"
    config ADSB_HOSTNAME
        string "DHCP hostname"
        default "adsb"
endmenu
```
